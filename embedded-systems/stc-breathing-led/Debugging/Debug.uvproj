# Keil uVision project Debug.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: Debug +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: delay.c main.c
